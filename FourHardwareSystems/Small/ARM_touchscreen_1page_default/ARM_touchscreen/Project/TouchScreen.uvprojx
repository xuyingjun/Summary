# Keil uVision project TouchScreen.uvprojx, settings and files
target TouchScreen (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TouchScreen +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CM3\CoreSupport;..\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Project;..\USER;..\startup
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ST
    ../startup/: startup_stm32f10x_hd.s
  group LIB
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_fsmc.c stm32f10x_iwdg.c
  group CM3
    ../CM3/CoreSupport/: core_cm3.c
    ../CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group USER
    ../USER/: main.c stm32f10_gpio.c stm32f10_timer.c stm32f10_usart.c stm32f10x_it.c LCD.c UI.c touch.c sys.c DHT11.c
software components: CMSIS:CORE 5.0.2
