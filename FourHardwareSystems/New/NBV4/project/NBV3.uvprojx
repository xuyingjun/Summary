# Keil uVision project NBV3.uvprojx, settings and files
target NBV3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NBV3 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\cm3\CoreSupport;..\cm3\DeviceSupport\ST\STM32F10x;..\libraries\inc;..\libraries\src;..\startup;..\user;..\hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ../cm3/CoreSupport/: core_cm3.c
    ../cm3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../startup/: startup_stm32f10x_hd.s
  group Hardware
    ../hardware/: ADS1115.c DAC8554.c Dio.c Globle.c MuxCfg.c myiic.c Pwm.c rtd.c stm32f10x_it.c systick_timer.c usart.c timer.c
  group User
    ../user/: main.c logic.c modbus.c modbusNew.c
  group Libraries
    ../libraries/src/: stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c misc.c
